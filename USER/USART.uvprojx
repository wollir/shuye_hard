# Keil uVision project USART.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RC STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\FWLIB\inc;..\HARDWARE\ADC;..\HARDWARE\PWM;..\ccd;.\my_task;..\HARDWARE\delay;..\HARDWARE\calman;..\HARDWARE\sht30
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: declaration.txt
    ../ccd/: ADC_conf.c main.c stm32f4xx_it.c system_stm32f4xx.c timer_conf.c UART_conf.c stm324xg_eval.c
    ./my_task/: wer_task.c
    ../HARDWARE/delay/: delay.c
  group HARDWARE
    ../HARDWARE/calman/: kalman.c
    ../HARDWARE/sht30/: myiic.c sht30.c
    ../HARDWARE/KEY/: key.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_i2c.c stm32f4xx_exti.c
